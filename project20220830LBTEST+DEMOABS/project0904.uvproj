# Keil uVision project project0904.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: project0904
  c flags: Optim=1 OneElfS=1
  c include: .\;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\Include\NUC1xx-LB_002
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./: startup_NUC1xx.s
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
  group Source files
    ./: mainsource0728ver2.c
    ../../../Src/NUC1xx-LB_002/: Ascii_Table.C
  group Library files
    ../../../Src/Driver/: DrvADC.c DrvGPIO.c DrvSPI.c DrvSYS.c DrvTIMER.c
